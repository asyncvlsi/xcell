*
* Include .lib for all the devices
*
.lib 'some_path_here' TT
